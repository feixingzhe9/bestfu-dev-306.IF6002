# Keil uVision project TouchPad_PhotoFrame.uvprojx, settings and files
target Target (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TouchPad_PhotoFrame_64K +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MD,STM32L151
  c include: ..\Core;..\Lib_code\App;..\Lib_code\SysHard\inc;..\Lib_code\SysLib\inc;..\User\Driver\ShakeMotor;..\User\Driver\USART1;..\User\Driver\WTC6106;..\User\Key;..\User\TouchPad_PhotoFrame;..\Lib_code\SysPower
  memory RVCT4: ROM 0x8005400 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Startup
    ../Core/: system_stm32l1xx.c startup_stm32l1xx_md.s
  group SysLib
    ../Lib_code/SysLib/: BestFu_STM32L15X_L10200.lib
  group SysHard
    ../Lib_code/SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c
    ../Lib_code/SysPower/: ADC.c Battery.c BatteryExeAttr.c LowPower.c
  group APP
    ../Lib_code/App/: main.c UnitCfg.c
  group Driver
    ../User/Driver/WTC6106/: WTC6106.c
    ../User/Driver/USART1/: USART1.c
    ../User/Driver/ShakeMotor/: ShakeMotor.c
  group Unit
    ../User/Key/: Key.c
  group Attr
    ../User/TouchPad_PhotoFrame/: KeyExeAttr.c
  group Readme
    ../: Readme.txt
